PACKAGECONFIG:append:pn-avahi = " libdns_sd"
