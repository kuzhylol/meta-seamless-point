NETWORKMANAGER_DNS_RC_MANAGER_DEFAULT = "symlink"
PACKAGECONFIG:remove = "dnsmasq "
PACKAGECONFIG:append = " man-resolv-conf"
