RDEPENDS:${PN} = "seamless-point-ap-ui"
