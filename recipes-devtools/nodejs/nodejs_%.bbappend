PACKAGECONFIG:remove = "ares brotli zlib"
