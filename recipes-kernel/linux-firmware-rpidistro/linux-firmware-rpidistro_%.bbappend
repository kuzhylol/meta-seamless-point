FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0002-Default-all-RPi-43455-boards-to-standard-variant.patch"
